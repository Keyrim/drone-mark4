# Repository Keyrim/drone-mark4 (continued)

## KiCad design hardware/mark4-fc/mark4-fc.kicad_pcb (continued)

Board: 4 copper layers, 103 parts (19 on the bottom side), 66 nets, no tracks yet.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_M3_3.2mm_Grommet

File hardware/mark4-fc/exports/mark4-fc-bom.csv:

"Reference","Value","Footprint","LCSC","MPN","Qty"
"BZ1","MLT-8540","mark4-fc:Buzzer_MLT-8540","C95300","MLT-8540","1"
"C1,C7-C11,C13,C14,C17,C20-C24","100nF","Capacitor_SMD:C_0603_1608Metric","C14663","CC0603KRX7R9BB104","14"
"C2,C5,C6,C25","10uF","Capacitor_SMD:C_0805_2012Metric","C15850","CL21A106KAYNNNE","4"
"C3,C4,C26","22uF","Capacitor_SMD:C_0805_2012Metric","C45783","CL21A226MAQNNNE","3"
"C12,C16","4.7uF","Capacitor_SMD:C_0805_2012Metric","C1779","CL21A475KAQNNNE","2"
"C15","1uF","Capacitor_SMD:C_0603_1608Metric","C15849","CL10A105KB8NNNC","1"
"C18,C19","8.2pF","Capacitor_SMD:C_0603_1608Metric","C1685","0603CG8R2C500NT","2"
"D3","BAT54W","Diode_SMD:D_SOD-123","C7502705","BAT54W","1"
"D4","KT-0603R","LED_SMD:LED_0603_1608Metric","C2286","KT-0603R","1"
"D5","NCD0603Y2","LED_SMD:LED_0603_1608Metric","C89811","NCD0603Y2","1"
"D6","1N4148W","Diode_SMD:D_SOD-123","C81598","1N4148W","1"
"J1","SWD","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","","","1"
"J2","USB_C_Receptacle_USB2.0_16P","Connector_USB:USB_C_Receptacle_HRO_TYPE-C-31-M-12","C165948","TYPE-C-31-M-12","1"
"JP1","BOOT0_FORCE","Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm","","","1"
"L1","4.7uH","mark4-fc:L_Sunlord_SWPA5040S","C48496","SWPA5040S4R7MT","1"
"Q1","SS8050","Package_TO_SOT_SMD:SOT-23","C2146","S8050","1"
"R1,R18","100k","Resistor_SMD:R_0603_1608Metric","C25803","0603WAF1003T5E","2"
"R2","12k","Resistor_SMD:R_0603_1608Metric","C22790","0603WAF1202T5E","1"
"R3-R5,R8-R10,R16,R20","10k","Resistor_SMD:R_0603_1608Metric","C25804","0603WAF1002T5E","8"
"R6,R7","4.7k","Resistor_SMD:R_0603_1608Metric","C23162","0603WAF4701T5E","2"
"R11,R12","5.1k","Resistor_SMD:R_0603_1608Metric","C23186","0603WAF5101T5E","2"
"R13-R15","1k","Resistor_SMD:R_0603_1608Metric","C21190","0603WAF1001T5E","3"
"R17","5R1","Resistor_SMD:R_0805_2012Metric","C17724","0805W8F510KT5E","1"
"R19","33k","Resistor_SMD:R_0603_1608Metric","C4216","0603WAF3302T5E","1"
"R21","330R","Resistor_SMD:R_0603_1608Metric","C23138","0603WAF3300T5E","1"
"TP1","PA8","TestPoint:TestPoint_Pad_D1.5mm","","","1"
"TP2","PB2","TestPoint:TestPoint_Pad_D1.5mm","","","1"
"TP3","PB4","TestPoint:TestPoint_Pad_D1.5mm","","","1"
"TP4","PD2","TestPoint:TestPoint_Pad_D1.5mm","","","1"
"TP5","TestPoint","TestPoint:TestPoint_Pad_D1.5mm","","","1"
"U1","AP63205WU","Package_TO_SOT_SMD:TSOT-23-6","C2071056","AP63205WU-7","1"
"U2","TLV1117LV33","Package_TO_SOT_SMD:SOT-223-3_TabPin2","C15578","TLV1117LV33DCYR","1"
"U3","STM32F722RETx","Package_QFP:LQFP-64_10x10mm_P0.5mm","C118207","STM32F722RET6","1"
"U4","LSM6DSR","Package_LGA:LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y","C784817","LSM6DSRTR","1"
"U5","SPA06-003","mark4-fc:Goertek_LGA-8_2x2.5mm_P0.65mm_ClockwisePinNumbering","C30589048","SPA06-003","1"
"U6","W25Q128JVSIQ","mark4-fc:SOIC-8_5.28x5.28mm_P1.27mm","C97521","W25Q128JVSIQ","1"
"U7","USBLC6-2SC6","Package_TO_SOT_SMD:SOT-23-6","C7519","USBLC6-2SC6","1"
"U8","TPS2116DRL","Package_TO_SOT_SMD:SOT-583-8","C3235557","TPS2116DRLR","1"
"Y1","8MHz","Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm","C712812","CJ13-080000910B20","1"
